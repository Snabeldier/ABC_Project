# Keil uVision project ApolloLoraMac.uvprojx, settings and files
target Target 1 (6240000::V6.24::ARMCLANG)
  device: AMA3B1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.5.4
  cpu: IRAM(0x10000000,0x00060000) IROM(0x0000C000,0x000F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Bachelorprojekt
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=1 wLevel=3
  c define: AM_PACKAGE_BGA AM_PART_APOLLO3 SOFT_SE REGION_EU868 ACTIVE_REGION=LORAMAC_REGION_EU868 HW_CF_SENSOR
  c include: ..\AmbiqSuite_R3.1.1\utils;..\AmbiqSuite_R3.1.1\mcu\apollo3;..\AmbiqSuite_R3.1.1\CMSIS\AmbiqMicro\Include;..\library-apollo-3-lo-ra-mac;..\apollo3_loramac;..\apollo3_loramac_library\boards;..\apollo3_loramac_library\system;..\apollo3_loramac_library\radio;..\apollo3_loramac_library\peripherals\soft-se;..\apollo3_loramac_library\peripherals;..\apollo3_loramac_library\mac;..\apollo3_loramac_library\mac\region;..\apollo3_loramac_library\apps\LoRaMac;..\apollo3_loramac_library\apps\LoRaMac\common;..\apollo3_loramac_library\apps\LoRaMac\common\LmHandler;..\apollo3_loramac_library\apps\LoRaMac\common\LmHandler\packages;..\apollo3_loramac_library\boards\Apollo3_V2
  memory RVCT4: ROM 0xc000 size 0xf4000
  memory RVCT9: RAM 0x10000000 size 0x60000
  group Project Source
    ./: main.c
  group lib
    ../AmbiqSuite_R3.1.1/mcu/apollo3/hal/: am_hal_adc.c am_hal_ble.c am_hal_ble_patch.c am_hal_ble_patch_b0.c am_hal_burst.c am_hal_cachectrl.c am_hal_clkgen.c am_hal_cmdq.c am_hal_ctimer.c am_hal_debug.c am_hal_entropy.c am_hal_flash.c am_hal_global.c am_hal_gpio.c am_hal_interrupt.c am_hal_iom.c am_hal_ios.c am_hal_itm.c am_hal_mcuctrl.c am_hal_mspi.c am_hal_pdm.c am_hal_pwrctrl.c am_hal_queue.c am_hal_reset.c am_hal_rtc.c am_hal_scard.c am_hal_secure_ota.c am_hal_security.c am_hal_stimer.c am_hal_sysctrl.c am_hal_systick.c am_hal_tpiu.c am_hal_uart.c am_hal_wdt.c
  group Application
    ./: periodicUplink.c periodicUplink.h payloadSweep.c payloadSweep.h deviceConfig.c deviceConfig.h
  group Drivers
    ../library-apollo-3-lo-ra-mac/: gpio.c gpio.h i2c.c i2c.h spi.c spi.h timing.c timing.h device.c device.h pins.h
  group Sensors & Storage
    ./: sht3x.c sht3x.h ina219.c ina219.h
    ../library-apollo-3-lo-ra-mac/: am1805.c am1805.h mb85rc64ta.c mb85rc64ta.h rtc.h
  group util
    ../AmbiqSuite_R3.1.1/utils/: am_util_ble.c am_util_debug.c am_util_delay.c am_util_faultisr.c am_util_id.c am_util_regdump.c am_util_stdio.c am_util_string.c am_util_time.c
  group Apollo3
    ../apollo3_loramac_library/boards/Apollo3_V2/: board.c eeprom-board.c gpio-board.c pinName-board.c pinName-ioe.c rtc-board.c spi-board.c sx126x-board.c utilities.c
    ../apollo3_loramac_library/boards/: board.h eeprom-board.h gpio-board.h pinName-board.h pinName-ioe.h rtc-board.h spi-board.h sx126x-board.h utilities.h
  group mac
    ../apollo3_loramac_library/mac/: LoRaMac.c LoRaMacAdr.c LoRaMacClassB.c LoRaMacCommands.c LoRaMacConfirmQueue.c LoRaMacCrypto.c LoRaMacParser.c LoRaMacSerializer.c LoRaMac.h LoRaMacAdr.h LoRaMacClassB.h LoRaMacClassBConfig.h LoRaMacClassBNvm.h LoRaMacCommands.h LoRaMacConfirmQueue.h LoRaMacCrypto.h LoRaMacCryptoNvm.h LoRaMacHeaderTypes.h LoRaMacMessageTypes.h LoRaMacParser.h LoRaMacSerializer.h LoRaMacTest.h LoRaMacTypes.h secure-element.h secure-element-nvm.h
  group region
    ../apollo3_loramac_library/mac/region/: Region.c RegionCommon.c RegionEU433.c RegionEU868.c Region.h RegionCommon.h RegionEU433.h RegionEU868.h RegionNvm.h
  group peripherals
    ../apollo3_loramac_library/peripherals/soft-se/: aes.c cmac.c soft-se.c soft-se-hal.c aes.h cmac.h se-identity.h soft-se-hal.h
  group radio
    ../apollo3_loramac_library/radio/: radio.c sx126x.c radio.h sx126x.h
  group system
    ../apollo3_loramac_library/system/: delay.c delay.h nvmm.c nvmm.h systime.c systime.h timer.c timer.h uart.c uart.h
  group LoRaMac
    ./: JalapenosLpp.c JalapenosLpp.h
    ../apollo3_loramac_library/apps/LoRaMac/common/: cli.c cli.h Commissioning.h githubVersion.h LmHandlerMsgDisplay.c LmHandlerMsgDisplay.h NvmDataMgmt.c NvmDataMgmt.h
    ../apollo3_loramac_library/apps/LoRaMac/common/LmHandler/: LmHandler.c LmHandler.h LmHandlerTypes.h
    ../apollo3_loramac_library/apps/LoRaMac/common/LmHandler/packages/: FragDecoder.c FragDecoder.h LmhPackage.h LmhpClockSync.c LmhpClockSync.h LmhpCompliance.c LmhpCompliance.h LmhpFragmentation.c LmhpFragmentation.h LmhpRemoteMcastSetup.c LmhpRemoteMcastSetup.h
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.14.2, Device:Startup 1.3.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
